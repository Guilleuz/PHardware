# Keil uVision project keil_reversi.uvproj, settings and files
target Simulator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: keil_reversi
  c flags: Optim=4 oTime=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: timer0.c timer0.h timer1.c timer1.h cola.h cola.c eventos.h gestor_energia.h gestor_energia.c reiniciarPLL.s gestor_alarmas.h gestor_alarmas.c gestor_pulsacion.c gestor_pulsacion.h Gestor_IO.c gpio.c Gestor_IO.h gpio.h sudoku_2021.c celda.h sudoku_2021.h tableros.h candidatos_actualizar_arm.s candidatos_actualizar_arm_c.s candidatos_propagar_arm.s main.c
